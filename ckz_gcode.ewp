# IAR project ckz_gcode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZE ST STM32F407ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx
  ICCARM.CCIncludePath2: Src\usblib\Core\Inc; Src\usblib\Class\HID\Inc; Src\usblib\Class\MSC\Inc; Src\usbapp; Src\FatFs; Src\FatFs\drivers; Src\stm32f4lib\Inc; Src\stm32f4lib\Inc\Legacy; Src\cm; Src\stm32f4lib; Src\mylib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Backup of ckz_gcode.hex
  ILINK.IlinkOutputFile: ckz_gcode.out
  ILINK.IlinkIcfFile: ckz_gcode_app.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group fatfs
    Src/FatFs/: diskio.c ff.c ff_gen_drv.c
    Src/FatFs/option/: syscall.c unicode.c
    Src/FatFs/drivers/: usbh_diskio.c
  group hardware
    Src/hardware/: anglogbus.c Encode.c iicbus.c inout.c led.c pwm.c serialbus.c ServoStep.c spibus.c timer.c w25qxx.c
  group modbus
    Src/modbus/: ModbusSlave.c
  group mylib
    Src/mylib/: delay.c stmflash.c sys.c
  group stm32f4lib
    Src/stm32f4lib/: startup_stm32f407xx.s stm32f4xx_it.c
    Src/stm32f4lib/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c
  group usbapp
    Src/usbapp/: fatfs.c usb_host.c usbh_conf.c
  group usblib/class/hid
    Src/usblib/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group usblib/class/msc
    Src/usblib/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group usblib/core
    Src/usblib/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group userapp
    Src/app/: Action.c Alarm.c AutoRun.c Gcode.c main.c Manual.c Touch.c usermemory.c
